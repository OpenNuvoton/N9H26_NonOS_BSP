# Keil uVision project SpiWriter.uvproj, settings and files
target N9H26_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_SpiWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_ __Security__
  c include: ..\..\..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: DrawFont.c Rootkey.c playsound.c ProcessIni.c ProcessOptionalIni.c spiflash.c standalone.c Writer.c wb_init.s
  group Lib
    ../../../../../BSP/Library/IPLib/: N9H26_GIANTPLUS_GPM1006D.lib N9H26_SYS.lib N9H26_SIC.lib N9H26_GPIO.lib N9H26_SPU.lib N9H26_Font_WVGA.lib N9H26_Font_QVGA.lib N9H26_SPI_SecureIC.lib N9H26_VPOST_FW050TFT_800x480.lib
    ../../../../../BSP/Library/NVTFATLib/: N9H26_NVTFAT.lib
target N9H26_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __Security__ __NoLCM__
  c include: ..\..\..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
