# Keil uVision project SDWriter.uvproj, settings and files
target QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: ..\..\..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: DrawFont.c ProcessIni.c ProcessOptionalIni.c standalone.c main.c wb_init.s
  group Lib
    ../../../../../BSP/Library/IPLib/: N9H26_SYS.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_SDIO.lib N9H26_SIC.lib N9H26_Font_QVGA.lib N9H26_Font_VGA.lib N9H26_Font_WQVGA.lib N9H26_Font_WVGA.lib N9H26_GPIO.lib
    ../../../../../BSP/Library/NVTFATLib/: N9H26_NVTFAT.lib
target WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
target WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: ..\..\..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
