# Keil uVision project SDLoader.uvproj, settings and files
target SDLoader_240MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_SDLoader_240MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_240__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
  group Src
    ../: Depop.c sd.c SdLoader.c standalone.c wb_aic.c wb_cache.c wb_config.c wb_mmu.c wb_power.c wb_timer.c wb_uart.c heap.s stack.s vectors.s wb_init.s
target SDLoader_not_set_clock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SDLoader_not_set_clock_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_NOT_SET__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
target SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SDLoader_192MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
target SDLoader_264MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SDLoader_264MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_264__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
