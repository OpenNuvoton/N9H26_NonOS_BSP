# Keil uVision project NandLoader.uvproj, settings and files
target NANDLoader_240MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_NANDLoader_240MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_240__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
  group Src
    ../: Depop.c NandDrv.c NandLoader.c standalone.c wb_aic.c wb_cache.c wb_config.c wb_mmu.c wb_power.c wb_timer.c wb_uart.c heap.s stack.s vectors.s wb_init.s
  group User_Define_Func
    ../user_define/: user_define_func.c
    ../../../BSP/Library/IPLib/: N9H26_GIANTPLUS_GPM1006D.lib
target NANDLoader_not_set_clock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_NANDLoader_not_set_clock_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_NOT_SET__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
target NANDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_NANDLoader_192MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
target NANDLoader_240MHz_Logo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_NANDLoader_240MHz_Fast_Logo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_240__ __USER_DEFINE_FUNC
  c include: ..; ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
target NANDLoader_264MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_NANDLoader_264MHz_Fast
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __UPLL_264__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
