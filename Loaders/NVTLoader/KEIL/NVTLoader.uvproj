# Keil uVision project NVTLoader.uvproj, settings and files
target SD_GIANTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVT_SDU0_Fast_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __LCM_QVGA__ __ENABLE_SD_CARD_0__ __NVT_DEV_DEMO_SD__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
  group Src
    ../: board_gaintplus.c NVT_avi.c NVT_boot_from_nand.c NVT_boot_from_sd.c NVT_Keypad.c NVT_main.c NVT_mass.c NVT_Voltagedetection.c NVT_vpost.c standalone.c heap.s stack.s vectors.s wb_init.s
  group Lib
    ../../../BSP/Library/IPLib/: N9H26_SYS.lib N9H26_ADC.lib N9H26_GPIO.lib N9H26_JPEG.lib N9H26_SIC.lib N9H26_SPU.lib N9H26_MSC_NAND.lib N9H26_MSC_SD.lib N9H26_UDC.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_KPI_2x3.lib N9H26_VPOST_FW050TFT_800x480.lib
    ../../../BSP/Library/AVILib/: N9H26_AVI.lib N9H26_IMA_ADPCM.lib
    ../../../BSP/Library/NVTFATLib/: N9H26_nvtfat.lib
    ../../../BSP/Library/GNANDLib/: N9H26_GNAND.lib
target NAND_GAINTPLUS_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_Fast_GIANTPLUS_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __LCM_QVGA__ __ENABLE_NAND_0__ __NVT_DEV_DEMO_NAND__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target SD_FW050TFT_800x480_24B (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SDU0_Fast_FW050TFT_800x480_24B
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __LCM_800x480__ __ENABLE_SD_CARD_0__ __NVT_DEV_DEMO_SD__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target NAND_FW050TFT_800x480_24B (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_NAND_Fast_FW050TFT_800x480_24B
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __LCM_800x480__ __ENABLE_NAND_0__ __NVT_DEV_DEMO_NAND__
  c include: ..\..\..\BSP\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
