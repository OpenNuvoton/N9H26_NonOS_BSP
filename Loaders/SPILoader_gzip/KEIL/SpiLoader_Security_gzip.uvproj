# Keil uVision project SpiLoader_Security_gzip.uvproj, settings and files
target 240MHz_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_SpiLoader(S)_gzip_240MHz_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=1 wLevel=2
  c define: __No_LCM__ __Security__ __UPLL_240__
  c include: ..\..\..\BSP\Driver\Include;..\ziplib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
  group Src
    ../: cmd_bootm.c main.c SpiRead.c standalone.c heap.s stack.s vectors.s wb_init.s Rootkey.c
    ../ziplib/: zlib.c
  group Lib
    ../../../BSP/Library/IPLib/: N9H26_SYS.lib N9H26_VPOST_FW050TFT_800x480.lib N9H26_SPU.lib N9H26_SPI_SecureIC.lib
target 240MHz_FW050TFT_800x480_24B (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader(S)_gzip_240MHz_FW050TFT_800x480_24
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=1 wLevel=2
  c define: __LCM_800x480__ __Security__ __UPLL_240__
  c include: ..\..\..\BSP\Driver\Include;..\ziplib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target 264MHz_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader(S)_gzip_264MHz_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=1 wLevel=2
  c define: __No_LCM__ __Security__ __UPLL_264__
  c include: ..\..\..\BSP\Driver\Include;..\ziplib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target 264MHz_FW050TFT_800x480_24B (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader(S)_gzip_264MHz_FW050TFT_800x480_24
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=1 wLevel=2
  c define: __LCM_800x480__ __Security__ __UPLL_264__
  c include: ..\..\..\BSP\Driver\Include;..\ziplib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target Not_Set_Clock_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader(S)_gzip_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=1 wLevel=2
  c define: __No_LCM__ __Security__ __UPLL_NOT_SET__
  c include: ..\..\..\BSP\Driver\Include;..\ziplib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target Not_Set_Clock_FW050TFT_800x480_24B (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader(S)_gzip_GiantPlus_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=1 wLevel=2
  c define: __LCM_800x480__ __Security__ __UPLL_NOT_SET__
  c include: ..\..\..\BSP\Driver\Include;..\ziplib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
