# Keil uVision project KPI.uvproj, settings and files
target KPI_2x3_NonBlock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: KPI_2x3_NonBlock
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _KPI_NONBLOCK_
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
  group Src
    ../: main.c standalone.c wb_init.s
  group Lib
    ../../../Library/IPLib/: N9H26_SYS.lib N9H26_GPIO.lib N9H26_KPI_2x3.lib
target KPI_2x3_Block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: KPI_2x3_Block
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
