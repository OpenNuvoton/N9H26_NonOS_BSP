# Keil uVision project Font.uvproj, settings and files
target QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Font_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: ..\..\..\Driver\Include\
  asm define: N9H26K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
  group Src
    ../: DrawFont.c standalone.c Font_demo.c wb_init.s
  group Lib
    ../../../Library/IPLib/: N9H26_Font_QVGA.lib N9H26_Font_VGA.lib N9H26_Font_WQVGA.lib N9H26_Font_WVGA.lib N9H26_SIC.lib N9H26_SYS.lib N9H26_GPIO.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_VPOST_FW050TFT_800x480.lib
    ../../../Library/GNANDLib/: N9H26_GNAND.lib
    ../../../Library/NVTFATLib/: N9H26_NVTFAT.lib
target WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Font_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: ..\..\..\Driver\Include\
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
target VGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Font_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_VGA_
  c include: ..\..\..\Driver\Include\
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
target WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Font_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\Driver\Include\
  asm define: N32903
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
