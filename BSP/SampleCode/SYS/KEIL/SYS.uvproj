# Keil uVision project SYS.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SYS
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
  group Src
    ../: demo_AIC.c demo_Cache.c demo_CLK.c demo_HUART.c demo_Timer.c demo_UART.c demo_wakeup.c standalone.c wb_init.s main.c
  group Lib
    ../../../Library/IPLib/: N9H26_GPIO.lib N9H26_SYS.lib
