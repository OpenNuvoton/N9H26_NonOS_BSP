# Keil uVision project VIN_DEMO.uvproj, settings and files
target PC2M01-2D01-GP-QVGA-Port1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: VIN_DEMO
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __DEV__ __1ST_PORT__
  c include: ..\..\..\Driver\Include\;..\I2CS;..\..\VideoIn
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: demo.c FileWrite.c jpegEnc.c Smpl_HM1375.c Smpl_I2C.c Smpl_NT99050.c Smpl_NT99141.c Smpl_NT99160.c Smpl_NT99252.c Smpl_NT99340.c Smpl_OV7670.c Smpl_OV7725.c Smpl_OV9660.c Smpl_VPOST.c Smpl_WT8861.c Smpl_GC0308.c Smpl_SA71113.c Smpl_SP1628.c Smpl_TW9912.c Smpl_TW9900.c Smpl_GM7150.c Smpl_NT99142.c Smpl_OV10633.c Smpl_SC1046.c Smpl_TVP5150.c Smpl_HM1246.c Smpl_HM2056.c
    ../Startup/: standalone.c wb_init.s
    ../../../Library/IPLib/: N9H26_VideoIn.lib N9H26_SYS.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_GPIO.lib N9H26_JPEG.lib N9H26_SIC.lib
    ../../../Library/NVTFATLib/: N9H26_NVTFAT.lib
    ../I2CS/: DrvI2C.c
target PC2M01-2D01-GP-QVGA-Port2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: VIN_DEMO
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __DEV__ __2ND_PORT__
  c include: ..\..\..\Driver\Include\;..\I2CS;..\..\VideoIn
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
