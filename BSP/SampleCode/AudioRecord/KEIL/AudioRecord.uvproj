# Keil uVision project AudioRecord.uvproj, settings and files
target DebugRel (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: AUR
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
  group Src
    ../: ADC_FileAccess.c AurExample.c EmuAudioRecord_Mono_AnalogMIC_AGC.c standalone.c wb_init.s AurEMDA.c
  group Lib
    ../../../Library/IPLib/: N9H26_SYS.lib N9H26_edma.lib N9H26_SIC.lib N9H26_SPU.lib N9H26_AUR.lib
    ../../../Library/NVTFATLib/: N9H26_NVTFAT.lib
