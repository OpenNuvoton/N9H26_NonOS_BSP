# Keil uVision project VPE.uvproj, settings and files
target VPE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: VPE
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: standalone.c wb_init.s main_vpe.c vpe_pattern.c
  group Lib
    ../../../Library/IPLib/: N9H26_SYS.lib N9H26_VPE.lib N9H26_VPOST_FW050TFT_800x480.lib
