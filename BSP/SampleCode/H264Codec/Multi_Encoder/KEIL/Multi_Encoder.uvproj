# Keil uVision project Multi_Encoder.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Multi_Encoder
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
  group Src
    ../: h264e.c ratecontrol.c standalone.c wb_init.s
  group Lib
    ../../../../Library/IPLib/: N9H26_SIC.lib N9H26_H264Codec.lib N9H26_SYS.lib
    ../../../../Library/NVTFATLib/: N9H26_nvtfat.lib
