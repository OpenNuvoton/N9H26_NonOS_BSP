# Keil uVision project TouchADC.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: demo.c demo_Integration.c demo_Keypad.c demo_Touchpanel.c demo_Voltagedetection.c EmuTouch_BitToggle.c EmuTouch_Reset.c standalone.c wb_init.s
  group Lib
    ../../../Library/IPLib/: N9H26_ADC.lib N9H26_SYS.lib
