# Keil uVision project RTC.uvproj, settings and files
target RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry Reset_Go
  group Src
    ../: standalone.c main.c powercontrol.c wb_init.s
  group Lib
    ../../../Library/IPLib/: N9H26_RTC.lib N9H26_SYS.lib
