# Keil uVision project RF.uvproj, settings and files
target DebugRel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: RF
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: main.c standalone.c wb_init.s
  group Lib
    ../../../Library/IPLib/: N9H26_EDMA.lib N9H26_RF.lib N9H26_SYS.lib N9H26_SIC.lib
    ../../../Library/NVTFATLib/: N9H26_NVTFAT.lib
