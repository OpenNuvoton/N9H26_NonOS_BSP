# Keil uVision project USBHost.uvproj, settings and files
target USBHost (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: USBHost
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry Reset_Go
  group Src
    ../: main.c wb_init.s usb_keyboard.c W99683.c
  group Lib
    ../../../../Library/USBH2.0Lib/: N9H26_UMAS.lib N9H26_USBH.lib
    ../../../../Library/NVTFATlib/: N9H26_NVTFAT.lib
    ../../../../Library/IPLib/: N9H26_SYS.lib
