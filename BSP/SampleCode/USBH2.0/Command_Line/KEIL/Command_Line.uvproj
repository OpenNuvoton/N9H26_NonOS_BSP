# Keil uVision project Command_Line.uvproj, settings and files
target Command_Line (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Command_Line
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: Demo_CommandShell.c NVTFAT_ERROR.C standalone.c wb_init.s
  group Lib
    ../../../../Library/USBH2.0Lib/: N9H26_UMAS.lib N9H26_USBH.lib
    ../../../../Library/IPLib/: N9H26_SYS.lib
    ../../../../Library/NVTFATlib/: N9H26_NVTFAT.lib
