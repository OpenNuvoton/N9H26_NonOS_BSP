# Keil uVision project Rotation.uvproj, settings and files
target ROT_LCM_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Rotation
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __LCM_320x240__
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry Reset_Go
  group Src
    ../: wb_init.s ROT_demo.c ROT_main.c Smpl_VPOST.c standalone.c
  group Lib
    ../../../Library/IPLib/: N9H26_Rot.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_SIC.lib N9H26_SYS.lib
    ../../../Library/NVTFATLib/: N9H26_NVTFAT.lib
