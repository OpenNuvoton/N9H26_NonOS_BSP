# Keil uVision project VPOST_N9H26_FW050TFT_800x480.uvproj, settings and files
target N9H26K6_FW050TFT_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: VPOST
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_800x480__
  c include: ..\ASIC;..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: standalone.c wb_init.s main.c
  group Lib
    ../../../Library/IPLib/: N9H26_SYS.lib N9H26_VPOST_FW050TFT_800x480.lib
