# Keil uVision project SimpleDemo.uvproj, settings and files
target Simple_N9H26K6_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SimpleDemo_N9H26K6_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Driver\Include;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\Application;..\tslib
  asm define: N9H26K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
  group Src
    ../: main.c wb_init.s standalone.c
  group Lib
    ../../../../Library/IPLib/: N9H26_SYS.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_VPOST_FW050TFT_800x480.lib N9H26_ADC.lib N9H26_SIC.lib N9H26_BLT.lib N9H26_JPEG.lib
    ../../../../Library/GNANDLib/: N9H26_GNAND.lib
    ../../../../Library/NVTFATLib/: N9H26_NVTFAT.lib
  group tslib
    ../tslib/: fbutils.c ts_calibrate.c testutils.c N9H26TouchPanel.c N9H26TouchPanel.h
  group GUI_Config
    ../../../../ThirdParty/emWin/Config/: LCDConf.c GUI_X.c GUIConf.c GUIConf.h
  group GUI_Lib
    ../../../../ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group Application
    ../Application/: FramewinDLG.c
target Simple_N9H26K6_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SmipleDemo_N9H26K6_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STORAGE_SD
  c include: as above
  asm define: N9H26K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
target Simple_N9H26K6_SD_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SimpleDemo_N9H26K6_SD_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf.exe --bin --output "$P../Bin/@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STORAGE_SD __800x480__
  c include: as above
  asm define: N9H26K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
