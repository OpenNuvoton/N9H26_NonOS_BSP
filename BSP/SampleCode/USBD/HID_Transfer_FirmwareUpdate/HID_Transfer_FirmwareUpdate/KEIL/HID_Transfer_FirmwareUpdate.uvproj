# Keil uVision project HID_Transfer_FirmwareUpdate.uvproj, settings and files
target HID_Transfer_FirmwareUpdate (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: HID_Transfer_FirmwareUpdate
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
  group Source Group
    ../: standalone.c wb_init.s main.c jpegDec.c
  group Lib
    ../../../../../Library/IPLib/: N9H26_VPOST_FW050TFT_800x480.lib N9H26_JPEG.lib N9H26_UDC.lib N9H26_SYS.lib
  group HID
    ../: HID.c spi.c spiflash.c SpiRead.c
