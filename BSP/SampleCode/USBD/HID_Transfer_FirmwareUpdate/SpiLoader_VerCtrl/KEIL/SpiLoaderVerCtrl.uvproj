# Keil uVision project SpiLoaderVerCtrl.uvproj, settings and files
target 240MHz_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_SpiLoader_240MHz_NoLCM_SpiLoader_VerCtrl
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __No_LCM__ __UPLL_240__
  c include: ..\..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
  group Src
    ../: main.c SpiRead.c standalone.c heap.s stack.s vectors.s wb_init.s
  group Lib
    ../../../../../Library/IPLib/: N9H26_SYS.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_SPU.lib
target 240MHz_GiantPlus_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader_240MHz_GiantPlus_QVGA_VerCtrl
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_320x240__ __UPLL_240__
  c include: ..\..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target 264MHz_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader_264MHz_NoLCM_VerCtrl
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __No_LCM__ __UPLL_264__
  c include: ..\..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target 264MHz_GiantPlus_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader_264MHz_GiantPlus_QVGA_VerCtrl
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_320x240__ __UPLL_264__
  c include: ..\..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target Not_Set_Clock_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader_NoLCM_VerCtrl
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __No_LCM__ __UPLL_NOT_SET__
  c include: ..\..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
target Not_Set_Clock_GiantPlus_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SpiLoader_GiantPlus_QVGA_VerCtrl
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCD_320x240__ __UPLL_NOT_SET__
  c include: ..\..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat.scf
  link misc: --entry Reset_Go
