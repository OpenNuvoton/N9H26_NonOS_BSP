# Keil uVision project mass_storage_FullSpeed_CDROM.uvproj, settings and files
target NAND0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: MSC_FS_CDROM_NAND0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__
  c include: ..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
  group Src
    ../: main.c standalone.c wb_init.s
  group Lib
    ../../../../Library/IPLib/: N9H26_MSC_NAND_CDROM.lib N9H26_MSC_NAND_SD_CDROM.lib N9H26_MSC_SD_CDROM.lib N9H26_MSC_RAM_CDROM.lib N9H26_MSC_SPI_CDROM.lib N9H26_SPI.lib N9H26_SYS.lib N9H26_SIC.lib N9H26_UDC_Fullspeed.lib
    ../../../../Library/NVTFATlib/: N9H26_NVTFAT.lib
    ../../../../Library/GNANDLib/: N9H26_GNAND.lib
target NAND&SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_FS_CDROM_NAND&SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD__
  c include: ..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
target SD0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_FS_CDROM_SD0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
target RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_FS_CDROM_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_ONLY__
  c include: ..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MSC_FS_CDROM_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: ..\..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry Reset_Go
