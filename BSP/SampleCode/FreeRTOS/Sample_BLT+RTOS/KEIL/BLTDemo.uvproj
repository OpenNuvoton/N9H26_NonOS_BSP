# Keil uVision project BLTDemo.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: BLTDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include;..\Startup;..\..\ARM9_N9H26;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include
  asm include: ..\..\ARM9_N9H26
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
  group Startup
    ../Startup/: wb_init.s standalone.c multithread.c task_state.c main.c
  group BLT
    ../: blt_main.c
  group Stadard Demo
    ../../Sample_RTOS/Demo/: PollQ_N9H2x.c BlockQ_N9H2x.c semtest_N9H2x.c dynamic_N9H2x.c
  group Lib
    ../../../../Library/IPLib/: N9H26_SYS_FreeRTOS.lib N9H26_BLT.lib N9H26_GIANTPLUS_GPM1006D.lib
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../ARM9_N9H26/: port.c portASM.s
