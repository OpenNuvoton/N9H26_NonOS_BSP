# Keil uVision project NVTFAT_FreeRTOS.uvproj, settings and files
target NVTFAT_FreeRTOS_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVTFAT_FreeRTOS
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=1
  c define: FREERTOS
  c include: ..\..\..\..\Driver\Include;..\..\..\FreeRTOS\ARM9_N9H26;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\StartUp
  asm define: N9H26K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
  group Startup
    ../StartUp/: main.c wb_init.s standalone.c multithread.c Retarget.c
  group Lib
    ../../../../Library/IPLib/: N9H26_SIC.lib N9H26_SYS_FreeRTOS.lib
    ../../../../Library/GNANDLib/: N9H26_GNAND.lib
    ../../../../Library/NVTFATLib/: N9H26_NVTFAT_FREERTOS.lib
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../../FreeRTOS/ARM9_N9H26/: port.c portASM.s
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
target NVTFAT_FreeRTOS_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_FreeRTOS
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=1
  c define: STORAGE_SD
  c include: as above
  asm define: N9H26K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
