# Keil uVision project AVI.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: AVI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Driver\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K5.sct
  link misc: --entry 0
  group Src
    ../: Demo_AVI.c standalone.c wb_init.s
  group Lib
    ../../../Library/IPLib/: N9H26_SIC.lib N9H26_GIANTPLUS_GPM1006D.lib N9H26_SPU.lib N9H26_JPEG.lib N9H26_SYS.lib
    ../../../Library/GNANDLib/: N9H26_GNAND.lib
    ../../../Library/NVTFATLib/: N9H26_nvtfat.lib
    ../../../Library/AVILib/: N9H26_AVI.lib N9H26_IMA_ADPCM.lib
