# Keil uVision project EDMA.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: EDMA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Driver\Include;..\..\VPOST\ASIC
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H26\N9H26K6.sct
  link misc: --entry 0
  group Src
    ../: main.c Smpl_Pdma_SPI.c Smpl_Pdma_UART.c Smpl_Vdma.c standalone.c wb_init.s
  group Lib
    ../../../Library/IPLib/: N9H26_SYS.lib N9H26_EDMA.lib N9H26_SPI.lib N9H26_GIANTPLUS_GPM1006D.lib
