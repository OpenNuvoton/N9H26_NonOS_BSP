# Keil uVision project GIANTPLUS_GPM1006.uvproj, settings and files
target GIANTPLUS_GPM1006 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_GIANTPLUS_GPM1006D (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __HAVE_GIANTPLUS_GPM1006D0__
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../: N92H26_VPOST.C N92H26_VPOST_Driver.c N92H26_VPOST_GIANTPLUS_GPM1006D0.c
