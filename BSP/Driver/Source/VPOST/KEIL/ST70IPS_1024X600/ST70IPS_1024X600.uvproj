# Keil uVision project ST70IPS_1024X600.uvproj, settings and files
target N9H26_ST70IPS_1024X600 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_VPOST_ST70IPS_1024X600 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: __HAVE_ST70IPS_1024x600__
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../: N9H26_VPOST.c N9H26_VPOST_Driver.c N9H26_VPOST_ST70IPS_1024X600.c
