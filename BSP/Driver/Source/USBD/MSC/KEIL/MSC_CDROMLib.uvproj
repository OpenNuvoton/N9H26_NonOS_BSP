# Keil uVision project MSC_CDROMLib.uvproj, settings and files
target SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_MSC_SD_CDROM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../MSC/: mscd.c
target NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_NAND_CDROM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_CDROM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target NAND&SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_NAND_SD_CDROM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_CDROM TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_RAM_CDROM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_All_CDROM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_CDROM TEST_SD TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_CDROM_Only (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_SPI_CDROM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM TEST_SPI
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
