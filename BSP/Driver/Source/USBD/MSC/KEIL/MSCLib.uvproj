# Keil uVision project MSCLib.uvproj, settings and files
target SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_MSC_SD (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../MSC/: mscd.c
target NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_NAND (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target NAND&SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_NAND_SD (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_RAM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_All (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_SD TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_MSC_SPI (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SPI
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
