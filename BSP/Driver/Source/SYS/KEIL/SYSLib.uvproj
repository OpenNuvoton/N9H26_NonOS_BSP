# Keil uVision project SYSLib.uvproj, settings and files
target Syslib (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_SYS (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: wb_aic.c wb_cache.c wb_config.c wb_mmu.c wb_power.c wb_timer.c wb_uart.c wb_dcache.s wb_sysctl.s wb_huart.c
target Syslib_FreeRTOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H26_SYS_FreeRTOS (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FreeRTOS__
  c include: ..\..\..\Include;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\.;..\..\..\..\SampleCode\FreeRTOS\ARM9_N9H26
  memory RVCT9: RAM 0xf8002000 size 0x8000
