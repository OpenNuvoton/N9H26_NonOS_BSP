# Keil uVision project H264CodecLib.uvproj, settings and files
target Disable_reorder (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_H264Codec (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 uC99=1 wLevel=2
  c define: _DISABLE_REORDER_ _USE_INT_ _RESET_IP_
  c include: ..\..\..\Include;..\Encoder;..\Decoder;..\..\H264Codec
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: favc_module.c h264_common.c Lib_wrapper.c nv_mem.c
    ../Decoder/: AVCdec.c decoder.c favc_dec_opt.c h264_funct.c
    ../Encoder/: bs.c common.c encoder.c favc_enc_opt.c memory.c sequence.c slice.c
