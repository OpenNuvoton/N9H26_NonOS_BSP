# Keil uVision project KPILib.uvproj, settings and files
target DebugRel_KPI_2X3 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_KPI_2x3 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: libkpi.c
