# Keil uVision project VPELib.uvproj, settings and files
target DebugRel (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H26_VPE (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: vpeIoctl.c vpelib.c
